File: Shield_Brazo_V1.0/Pinout.kicad_sch (KiCad schematic)
At the start: 9 parts, among them J3 I2C, J4 UART

Commit message: Placa Terminada!
Parts:
- H1, H2, H3, H4: value ~ -> (none)
